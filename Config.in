## three-digits_dt/Config.in
```kconfig
config BR2_PACKAGE_THREE_DIGITS_DT
	bool "Device tree for the three-digits module"
```
